Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-03-18T08:17:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 18 08:17:20 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\2424abfd-4859-4e72-9304-bfa5b83a34b1\3b7b07ff-bdb0-4642-9deb-f3604201aa93\ifc * Database version: 5507 * Database creation date: Mon Mar 18 08:17:18 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 18 08:17:19 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 18 08:17:19 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12394350_CN_DA3966C_EDST:28W3966S_CN_12394350_DA3966C_EDST, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 28W3966S_CN_12394350_DA3966C_EDST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28W3966S_CN_12394350_DA3966C_EDST
Material: z_Miele_Design_CLST, z_Miele_Design_Glass, z_Miele_Design_Glass Black, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
